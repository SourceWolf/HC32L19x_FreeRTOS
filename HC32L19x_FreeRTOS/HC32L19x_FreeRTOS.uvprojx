# Keil uVision project HC32L19x_FreeRTOS.uvprojx, settings and files
target HC32L19x_FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32L196PCTA HDSC
  pack: HDSC.HC32L19X.1.0.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HC32L19x_FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\freertos-7.4.2\Source\include;.\driver\inc;.\hardware;.\mcu\common;.\App;.\freertos-7.4.2\Source\portable\RVDS\ARM_CM0;.\freertos-7.4.2\Source\CMSIS_RTOS;.\Midware
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --keep=*Handler
  group App
    ./App/: app_task.c app_task.h ddl_device.h FreeRTOSConfig.h main.c
  group FreeRTOS
    ./freertos-7.4.2/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./freertos-7.4.2/Source/portable/MemMang/: heap_4.c
    ./freertos-7.4.2/Source/portable/RVDS/ARM_CM0/MDK/: port.c
    ./freertos-7.4.2/Source/CMSIS_RTOS/: cmsis_os.c
  group lib
    ./driver/src/: adc.c adt.c aes.c bgr.c bt.c crc.c dac.c ddl.c debug.c dmac.c flash.c gpio.c i2c.c lcd.c lpm.c lptim.c lpuart.c lvd.c opa.c pca.c pcnt.c ram.c reset.c rtc.c spi.c sysctrl.c timer3.c trim.c trng.c uart.c vc.c wdt.c
  group MCU
    ./mcu/common/: interrupts_hc32l19x.c system_hc32l19x.c
    ./mcu/MDK/: startup_hc32l19x.s
  group Hardware
    ./hardware/: hd_adc.c hd_adc.h hd_can.c hd_can.h hd_gpio.c hd_gpio.h hd_gpt_timer.c hd_gpt_timer.h hd_pca.c hd_pca.h hd_uart1.c hd_uart1.h hd_lptimer.c hd_lptimer.h hd_deepsleep.c hd_deepsleep.h hd_spi.c hd_spi.h
  group Midware
    ./Midware/: NRF24L01.c NRF24L01.h
software components: CMSIS:CORE 5.3.0
