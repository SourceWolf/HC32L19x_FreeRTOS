# IAR project HC32L19x_FreeRTOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: App; driver\inc; freertos-7.4.2\Source\include; freertos-7.4.2\Source\CMSIS_RTOS; freertos-7.4.2\Source\portable\RVDS\ARM_CM0; mcu\common; hardware; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: HC32L19x_FreeRTOS.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    App/: app_task.c app_task.h ddl_device.h FreeRTOSConfig.h main.c
  group FreeRTOS
    freertos-7.4.2/Source/CMSIS_RTOS/: cmsis_os.c
    freertos-7.4.2/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    freertos-7.4.2/Source/portable/MemMang/: heap_4.c
    freertos-7.4.2/Source/portable/RVDS/ARM_CM0/: port.c portasm.s portmacro.h
  group lib
    driver/src/: adc.c adt.c aes.c bgr.c bt.c crc.c dac.c ddl.c debug.c dmac.c flash.c gpio.c i2c.c lcd.c lpm.c lptim.c lpuart.c lvd.c opa.c pca.c pcnt.c ram.c reset.c rtc.c spi.c sysctrl.c timer3.c trim.c trng.c uart.c vc.c wdt.c
  group MCU
    mcu/common/: base_types.h board_stkhc32l19x.h hc32l19x.h interrupts_hc32l19x.c interrupts_hc32l19x.h system_hc32l19x.c system_hc32l19x.h
    mcu/EWARM/: startup_hc32l19x.s
